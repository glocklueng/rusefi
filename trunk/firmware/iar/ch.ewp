# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\chibios\os\kernel\include; ..\chibios\os\ports\common\ARMCMx; ..\chibios\os\ports\common\ARMCMx\CMSIS\include; ..\chibios\os\ports\IAR\ARMCMx; ..\chibios\os\ports\IAR\ARMCMx\STM32F4xx; ..\chibios\os\hal\include; ..\chibios\os\hal\platforms\STM32; ..\chibios\os\hal\platforms\STM32\DMAv1; ..\chibios\os\hal\platforms\STM32\GPIOv2; ..\chibios\os\hal\platforms\STM32\I2Cv1; ..\chibios\os\hal\platforms\STM32\SPIv1; ..\chibios\os\hal\platforms\STM32\TIMv1; ..\chibios\os\hal\platforms\STM32\RTCv2; ..\chibios\os\hal\platforms\STM32\USARTv1; ..\chibios\os\hal\platforms\STM32\OTGv1; ..\chibios\os\hal\platforms\STM32F4xx; ..\chibios\os\various; ..\chibios\os\various\devices_lib\accel; ..\chibios\boards\ST_STM32F4_DISCOVERY; ..\controllers; ..\controllers\algo; ..\controllers\core; ..\controllers\system; ..\controllers\sensors; ..\controllers\math; ..\controllers\trigger; ..\console; ..\config; ..\config\engines; ..\config\stm32f4ems; ..\console\binary; ..\console_util; ..\development; ..\development\test; ..\development\hw_layer; ..\hw_layer\algo; ..\hw_layer\lcd; ..\hw_layer\stm32f4; ..\hw_layer\serial_over_usb; ..\hw_layer; ..\ext; ..\ext_algo; ..\development; ..\development\hw_layer; ..\util
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..; ..\chibios\os\ports\IAR\ARMCMx\STM32F4xx; ..\chibios\boards\ST_STM32F4_DISCOVERY
  OBJCOPY.OOCOutputFile: iar.hex
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\chibios\os\kernel\include; ..\chibios\os\ports\common\ARMCMx; ..\chibios\os\ports\common\ARMCMx\CMSIS\include; ..\chibios\os\ports\IAR\ARMCMx; ..\chibios\os\ports\IAR\ARMCMx\STM32F4xx; ..\chibios\os\hal\include; ..\chibios\os\hal\platforms\STM32; ..\chibios\os\hal\platforms\STM32\DMAv1; ..\chibios\os\hal\platforms\STM32\GPIOv2; ..\chibios\os\hal\platforms\STM32\SPIv1; ..\chibios\os\hal\platforms\STM32\TIMv1; ..\chibios\os\hal\platforms\STM32\USARTv1; ..\chibios\os\hal\platforms\STM32F4xx; ..\chibios\os\various; ..\chibios\os\various\devices_lib\accel; ..\chibios\boards\ST_STM32F4_DISCOVERY; ..\..\..\test
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ch.hex
  group (top)
    ../: chconf.h global.h halconf.h main.cpp main.h mcuconf.h rusefi.cpp rusefi.h svnversion.h
  group config/engines
    ../config/engines/: acura_rsx.cpp acura_rsx.h audi_aan.cpp audi_aan.h bmw_e34.cpp bmw_e34.h chevrolet_c20_1973.cpp chevrolet_c20_1973.h chevrolet_camaro_4.cpp chevrolet_camaro_4.h citroenBerlingoTU3JP.cpp citroenBerlingoTU3JP.h custom_engine.cpp custom_engine.h daihatsu.cpp daihatsu.h dodge_neon.cpp dodge_neon.h dodge_ram.cpp dodge_ram.h dodge_stratus.cpp dodge_stratus.h engines.h ford_1995_inline_6.cpp ford_1995_inline_6.h ford_aspire.cpp ford_aspire.h ford_festiva.cpp ford_festiva.h ford_fiesta.cpp ford_fiesta.h gm_2_2.cpp gm_2_2.h GY6_139QMB.cpp GY6_139QMB.h honda_accord.cpp honda_accord.h mazda_323.cpp mazda_323.h mazda_626.cpp mazda_626.h mazda_miata.cpp mazda_miata.h mazda_miata_nb.cpp mazda_miata_nb.h MiniCooperR50.cpp MiniCooperR50.h mitsubishi.cpp mitsubishi.h nissan_primera.cpp nissan_primera.h rover_v8.cpp rover_v8.h sachs.cpp sachs.h saturn_ion.cpp saturn_ion.h snow_blower.cpp snow_blower.h subaru.cpp subaru.h suzuki_vitara.cpp suzuki_vitara.h test_engine.cpp test_engine.h toyota_jzs147.cpp toyota_jzs147.h vw.cpp vw.h
  group config/stm32f4ems
    ../config/stm32f4ems/: chconf.h efifeatures.h halconf.h mcuconf.h
  group console
    ../console/: console_io.cpp console_io.h eficonsole.cpp eficonsole.h status_loop.cpp status_loop.h
  group console/binary
    ../console/binary/: tunerstudio.cpp tunerstudio.h tunerstudio_configuration.h tunerstudio_io.cpp tunerstudio_io.h
  group console_util
    ../console_util/: rfiutil.c rfiutil.h
  group controllers
    ../controllers/: alternatorController.cpp alternatorController.h electronic_throttle.cpp electronic_throttle.h engine_controller.cpp engine_controller.h error_handling.cpp flash_main.cpp flash_main.h idle_thread.cpp idle_thread.h injector_central.cpp injector_central.h lcd_controller.cpp lcd_controller.h malfunction_indicator.cpp malfunction_indicator.h map_averaging.cpp map_averaging.h obd2.cpp obd2.h obd2viaCAN.c PwmTester.cpp PwmTester.h settings.cpp settings.h tachometer.cpp tachometer.h
  group controllers/algo
    ../controllers/algo/: accel_enrichment.cpp accel_enrichment.h advance_map.cpp advance_map.h algo.cpp algo.h auto_generated_enums.cpp auto_generated_enums.h can_header.h ec2.h engine.cpp engine.h engine_configuration.cpp engine_configuration.h engine_state.h error_handling.h event_registry.cpp event_registry.h fuel_math.cpp fuel_math.h idle_controller.cpp idle_controller.h io_pins.h lcd_menu_tree.cpp lcd_menu_tree.h main_trigger_callback.h malfunction_central.c malfunction_central.h map_adjuster.c map_adjuster.h nmea.c nmea.h obd_error_codes.h rusefi_enums.h signal_executor.cpp signal_executor.h
  group controllers/core
    ../controllers/core/: avg_values.cpp avg_values.h EfiWave.cpp EfiWave.h fsio_core.cpp fsio_core.h fsio_impl.cpp fsio_impl.h interpolation.cpp interpolation.h signal_filtering.c signal_filtering.h table_helper.cpp table_helper.h
  group controllers/math
    ../controllers/math/: efitime.h engine_math.cpp engine_math.h pid.cpp pid.h speed_density.cpp speed_density.h
  group controllers/sensors
    ../controllers/sensors/: allsensors.cpp allsensors.h ego.cpp ego.h hip9011_lookup.cpp hip9011_lookup.h maf.cpp maf.h map.cpp map.h sensor_types.h thermistors.cpp thermistors.h tps.cpp tps.h voltage.cpp voltage.h
  group controllers/system
    ../controllers/system/: efiGpio.cpp efiGpio.h event_queue.cpp event_queue.h pwm_generator_logic.cpp pwm_generator_logic.h scheduler.h signal_executor_sleep.cpp signal_executor_sleep.h SingleTimerExecutor.cpp SingleTimerExecutor.h
  group controllers/trigger
    ../controllers/trigger/: main_trigger_callback.cpp rpm_calculator.cpp rpm_calculator.h trigger_bmw.cpp trigger_bmw.h trigger_central.cpp trigger_central.h trigger_chrysler.cpp trigger_chrysler.h trigger_decoder.cpp trigger_decoder.h trigger_emulator_algo.cpp trigger_emulator_algo.h trigger_gm.cpp trigger_gm.h trigger_mazda.cpp trigger_mazda.h trigger_mitsubishi.cpp trigger_mitsubishi.h trigger_nissan.cpp trigger_nissan.h trigger_rover.cpp trigger_rover.h trigger_simulator.cpp trigger_simulator.h trigger_structure.cpp trigger_structure.h trigger_subaru.cpp trigger_subaru.h trigger_toyota.cpp trigger_toyota.h
  group development
    ../development/: engine_emulator.cpp engine_emulator.h engine_sniffer.cpp engine_sniffer.h rfi_perftest.cpp rfi_perftest.h sensor_chart.cpp sensor_chart.h trigger_emulator.cpp trigger_emulator.h wave_analyzer.cpp wave_analyzer.h
  group development/hw_layer
    ../development/hw_layer/: poten.cpp poten.h
  group development/test
    ../development/test/: test.c test.h testbmk.c testbmk.h
  group ext
    ../chibios/ext/fatfs/src/option/: ccsbcs.c
    ../ext/: diskio.h ff.h ffconf.h integer.h
    ../chibios/ext/fatfs/src/: ff.c
  group hw_layer
    ../hw_layer/: adc_external.h adc_inputs.cpp adc_inputs.h AdcConfiguration.h board_test.cpp board_test.h can_hw.cpp can_hw.h digital_input_hw.cpp digital_input_hw.h flash.c flash.h gpio_helper.cpp gpio_helper.h hardware.cpp hardware.h HIP9011.cpp HIP9011.h io_pins.cpp joystick.cpp joystick.h max31855.cpp max31855.h mcp3208.c mcp3208.h microsecond_timer.cpp microsecond_timer.h mmc_card.cpp mmc_card.h neo6m.cpp neo6m.h pin_repository.cpp pin_repository.h pwm_generator.cpp pwm_generator.h rtc_helper.cpp rtc_helper.h stepper.cpp stepper.h stm32f4xx_specific.h trigger_input.cpp trigger_input.h vehicle_speed.cpp vehicle_speed.h wbo.cpp wbo.h
  group hw_layer/algo
    ../hw_layer/algo/: adc_math.h
  group hw_layer/lcd
    ../hw_layer/lcd/: lcd_HD44780.cpp lcd_HD44780.h
  group hw_layer/serial_over_usb
    ../hw_layer/serial_over_usb/: usbcfg.c usbcfg.h usbconsole.c usbconsole.h
  group hw_layer/stm32f4
    ../hw_layer/stm32f4/: mpu_util.cpp mpu_util.h
  group os/board
    ../chibios/boards/ST_STM32F4_DISCOVERY/: board.c board.h
  group os/hal/include
    ../chibios/os/hal/include/: adc.h can.h ext.h gpt.h hal.h i2c.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h uart.h usb.h usb_cdc.h
  group os/hal/src
    ../chibios/os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c mmcsd.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c uart.c usb.c
    ../chibios/os/hal/platforms/STM32/: ext_lld.c
    ../chibios/os/hal/platforms/STM32F4xx/: ext_lld_isr.c
  group os/kernel/include
    ../chibios/os/kernel/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../chibios/os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/platform
    ../chibios/os/hal/platforms/STM32F4xx/: adc_lld.c adc_lld.h hal_lld.c hal_lld.h stm32_dma.c stm32_dma.h stm32_rcc.h stm32f4xx.h
    ../chibios/os/hal/platforms/STM32/: can_lld.c can_lld.h
    ../chibios/os/hal/platforms/STM32/TIMv1/: gpt_lld.c gpt_lld.h icu_lld.c icu_lld.h pwm_lld.c pwm_lld.h stm32_tim.h
    ../chibios/os/hal/platforms/STM32/I2Cv1/: i2c_lld.c i2c_lld.h
    ../chibios/os/hal/platforms/STM32/GPIOv2/: pal_lld.c pal_lld.h
    ../chibios/os/hal/platforms/STM32/RTCv2/: rtc_lld.c rtc_lld.h
    ../chibios/os/hal/platforms/STM32/USARTv1/: serial_lld.c serial_lld.h
    ../chibios/os/hal/platforms/STM32/SPIv1/: spi_lld.c spi_lld.h
    ../chibios/os/hal/platforms/STM32/OTGv1/: stm32_otg.h usb_lld.c usb_lld.h
  group os/port
    ../chibios/os/ports/IAR/ARMCMx/: chcore.c chcore.h chcore_v7m.c chcore_v7m.h chcoreasm_v7m.s chtypes.h cstartup.s
    ../chibios/os/ports/common/ARMCMx/: nvic.c nvic.h
  group os/port/STM32F4xx
    ../chibios/os/ports/IAR/ARMCMx/STM32F4xx/: cmparams.h vectors.s
  group os/various
    ../chibios/os/various/: chprintf.c chprintf.h chrtclib.c chrtclib.h memstreams.c memstreams.h
    ../chibios/os/various/fatfs_bindings/: fatfs_diskio.c fatfs_syscall.c
  group util
    ../util/: cli_registry.cpp cli_registry.h crc.c crc.h cyclic_buffer.cpp cyclic_buffer.h data_buffer.c data_buffer.h datalogging.cpp datalogging.h efilib.cpp efilib.h efilib2.cpp efilib2.h histogram.c histogram.h listener_array.cpp listener_array.h LocalVersionHolder.cpp LocalVersionHolder.h loggingcentral.cpp loggingcentral.h
