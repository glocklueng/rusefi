# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORTEX_USE_FPU=FALSE
  ICCARM.CCIncludePath2: ..\; ..\chibios\os\kernel\include; ..\chibios\os\ports\common\ARMCMx; ..\chibios\os\ports\common\ARMCMx\CMSIS\include; ..\chibios\os\ports\IAR\ARMCMx; ..\chibios\os\ports\IAR\ARMCMx\STM32F4xx; ..\chibios\os\hal\include; ..\chibios\os\hal\platforms\STM32; ..\chibios\os\hal\platforms\STM32\DMAv1; ..\chibios\os\hal\platforms\STM32\GPIOv2; ..\chibios\os\hal\platforms\STM32\SPIv1; ..\chibios\os\hal\platforms\STM32\TIMv1; ..\chibios\os\hal\platforms\STM32\USARTv1; ..\chibios\os\hal\platforms\STM32F4xx; ..\chibios\os\various; ..\chibios\os\various\devices_lib\accel; ..\config\system; ..\chibios\boards\ST_STM32F4_DISCOVERY; ..\chibios\os\hal\platforms\STM32\OTGv1; ..\config; ..\emulation; ..\emulation\hw_layer; ..\hw_layer; ..\russianefi; ..\russianefi\adc; ..\russianefi\algo; ..\russianefi\ckp; ..\settings; ..\splib; ..\tunerstudio; ..\controllers; ..\controllers\algo; ..\controllers\math; ..\util; ..\console; ..\console_util; ..\config\engines; ..; ..\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORTEX_USE_FPU=FALSE
  AARM.AUserIncludes: ..; ..\chibios\os\ports\IAR\ARMCMx\STM32F4xx; ..\..\..\boards\ST_STM32F4_DISCOVERY; ..\config\system
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: CORTEX_USE_FPU=FALSE; NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\chibios\os\kernel\include; ..\chibios\os\ports\common\ARMCMx; ..\chibios\os\ports\common\ARMCMx\CMSIS\include; ..\chibios\os\ports\IAR\ARMCMx; ..\chibios\os\ports\IAR\ARMCMx\STM32F4xx; ..\chibios\os\hal\include; ..\chibios\os\hal\platforms\STM32; ..\chibios\os\hal\platforms\STM32\DMAv1; ..\chibios\os\hal\platforms\STM32\GPIOv2; ..\chibios\os\hal\platforms\STM32\SPIv1; ..\chibios\os\hal\platforms\STM32\TIMv1; ..\chibios\os\hal\platforms\STM32\USARTv1; ..\chibios\os\hal\platforms\STM32F4xx; ..\chibios\os\various; ..\chibios\os\various\devices_lib\accel; ..\..\..\boards\ST_STM32F4_DISCOVERY; ..\..\..\test
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.AUserIncludes: ..; ..\chibios\os\ports\IAR\ARMCMx\STM32F4xx; ..\..\..\boards\ST_STM32F4_DISCOVERY
  OBJCOPY.OOCOutputFile: ch.hex
  group (top)
    ../: main.c main.h
  group chibios/boards/ST_STM32F4_DISCOVERY
    ../chibios/boards/ST_STM32F4_DISCOVERY/: board.c board.h
  group config/engines
    ../config/engines/: engine.h ford_aspire.c ford_aspire.h snow_blower.c snow_blower.h
  group config/system
    ../config/system/: chconf.h halconf.h mcuconf.h
  group console
    ../console/: console_io.c console_io.h rficonsole.c rficonsole.h status_loop.c status_loop.h tunerstudio.c tunerstudio.h usbcfg.c usbcfg.h usbconsole.c usbconsole.h
  group console_util
    ../console_util/: datalogging.c datalogging.h print.c print.h rficonsole_logic.c rficonsole_logic.h rfiutil.c rfiutil.h
  group controllers
    ../controllers/: advance_map.c advance_map.h engine_controller.c engine_controller.h flash_main.c flash_main.h idle_thread.c idle_thread.h injector_central.c injector_central.h main_loop.c main_loop.h map_multiplier_thread.c map_multiplier_thread.h rpm_reporter.c rpm_reporter.h settings.c settings.h signal_executor.c signal_executor.h
  group controllers/algo
    ../controllers/algo/: fuel_map.c fuel_map.h idle_controller.c idle_controller.h map_adjuster.c map_adjuster.h
  group controllers/math
    ../controllers/math/: avg_values.c avg_values.h engine_math.c engine_math.h signal_filtering.c signal_filtering.h thermistors.c thermistors.h
  group emulation
    ../emulation/: dist_emulator.c dist_emulator.h engine_emulator.c engine_emulator.h wave_analyzer.c wave_analyzer.h wave_chart.c wave_chart.h
  group emulation/hw_layer
    ../emulation/hw_layer/: poten.c poten.h
  group hw_layer
    ../hw_layer/: adc_external.h adc_inputs.c adc_inputs.h adc_internal_common.h adc_internal_dual_amp.h adc_internal_nice_board.h ckp_events.h crank_input.c crank_input.h flash.c flash.h gpio_helper.c gpio_helper.h hardware.c hardware.h mcp3208.c mcp3208.h output_pins.c output_pins.h pin_repository.c pin_repository.h pwm_generator.c pwm_generator.h stm32f4xx_specific.h wave_analyzer_hw.c wave_analyzer_hw.h
  group os/hal/include
    ../chibios/os/hal/include/: adc.h can.h ext.h gpt.h hal.h i2c.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h uart.h usb.h usb_cdc.h
    ../chibios/os/hal/platforms/STM32/TIMv1/: gpt_lld.h icu_lld.h stm32_tim.h
    ../chibios/os/hal/platforms/STM32/OTGv1/: stm32_otg.h usb_lld.h
  group os/hal/src
    ../chibios/os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c uart.c usb.c
    ../chibios/os/hal/platforms/STM32/TIMv1/: gpt_lld.c icu_lld.c
    ../chibios/os/hal/platforms/STM32/OTGv1/: usb_lld.c
  group os/kernel/include
    ../chibios/os/kernel/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../chibios/os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/platform
    ../chibios/os/hal/platforms/STM32F4xx/: adc_lld.c adc_lld.h hal_lld.c hal_lld.h stm32_dma.c stm32_dma.h stm32_rcc.h stm32f4xx.h
    ../chibios/os/hal/platforms/STM32/GPIOv2/: pal_lld.c pal_lld.h
    ../chibios/os/hal/platforms/STM32/TIMv1/: pwm_lld.c pwm_lld.h
    ../chibios/os/hal/platforms/STM32/USARTv1/: serial_lld.c serial_lld.h
    ../chibios/os/hal/platforms/STM32/SPIv1/: spi_lld.c spi_lld.h
  group os/port
    ../chibios/os/ports/IAR/ARMCMx/: chcore.c chcore.h chcore_v7m.c chcore_v7m.h chcoreasm_v7m.s chtypes.h cstartup.s
    ../chibios/os/ports/common/ARMCMx/: nvic.c nvic.h
  group os/port/STM32F4xx
    ../chibios/os/ports/IAR/ARMCMx/STM32F4xx/: cmparams.h vectors.s
  group util
    ../util/: crc.c crc.h data_buffer.c data_buffer.h global.h listener_array.c listener_array.h wave_math.c wave_math.h
